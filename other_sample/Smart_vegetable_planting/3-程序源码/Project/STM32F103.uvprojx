# Keil uVision project STM32F103.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\HMAC\inc;..\HMAC\scr;..\Lib\inc;..\Lib\src;..\Startup;..\User;..\Basic\sys;..\Basic\tim;..\Basic\i2c;..\Basic\adc;..\Basic\delay;..\Basic\usart;..\Hardware\LED;..\Hardware\CAT1;..\Hardware\24CXX;..\Hardware\AHT10;..\Hardware\BH1750;..\Hardware\MOTOR;..\Hardware\SWITCH;..\Hardware\AliDATA;..\Hardware\MONITOR;..\Basic\exti
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group User
    ../User/: main.c stm32f10x_it.c
  group Basic
    ../Basic/sys/: sys.c
    ../Basic/i2c/: i2c.c
    ../Basic/adc/: adc.c
    ../Basic/exti/: exti.c
    ../Basic/tim/: tim2.c tim3.c tim4.c
    ../Basic/delay/: delay.c
    ../Basic/usart/: usart1.c usart2.c
  group Hardware
    ../Hardware/CAT1/: cat1.c
    ../Hardware/24CXX/: 24cxx.c
    ../Hardware/AHT10/: aht10.c
    ../Hardware/MOTOR/: motor.c
    ../Hardware/SWITCH/: switch.c
    ../Hardware/AliDATA/: alidata.c
    ../Hardware/BH1750/: bh1750.c
    ../Hardware/MONITOR/: monitor.c
  group HMAC
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
